Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Número do projeto
Time: 2024-12-07T18:00:43
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200210_1400(x64) - Exporter 20.2.12.1 - IU alternativa 20.2.12.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sat Dec 07 18:00:43 2024 * Host: fuleco * Database: C:\Users\jujus\AppData\Local\Temp\f897a013-d730-4de6-a941-82b9684d09e0\b9219a18-ce11-4013-9152-4e3eeb52ab3f\ifc * Database version: 5507 * Database creation date: Sat Dec 07 18:00:43 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sat Dec 07 18:00:43 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sat Dec 07 18:00:43 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Número do projeto
LongName: Nome do projeto; Phase: Status do projeto

# IfcSite, Default
RefLatitude: 42, 12, 46, 804504; RefLongitude: -71, -2, 0, -602416; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 0
